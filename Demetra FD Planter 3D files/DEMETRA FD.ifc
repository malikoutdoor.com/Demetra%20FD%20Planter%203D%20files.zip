Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:48:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:48:15 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{DA0896C2-916B-42E6-AF25-D2A5906B83CD}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:48:15 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:48:15 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:48:15 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0FIAR032 - WITHOUT LEVELLING - VERDE ALPI - 170 Lt, Fioriera DEMETRA FD:0FIAR032 - WITHOUT LEVELLING - VERDE ALPI - 170 Lt:173187
In: 0 - Piano Terra
Type - Material: VERDE ALLPI
Type - Altro - Categoria: Modelli generici; Nome famiglia: Fioriera DEMETRA FD
Type - Dati identità - BIM Name: DEMETRA FD SENZA LIVELLAMENTO - 170 L; BIM Object Type: FIORIERE - PLANTERS; Code: 0FIAR032; Designer: BELLITALIA DESIGN; Family Name: DEMETRA; Nome del tipo: 0FIAR032 - WITHOUT LEVELLING - VERDE ALPI - 170 Lt; URL Eng: https://www.bellitalia.net/en/products/planters/demetra-f/; URL Ita: https://www.bellitalia.net/prodotti/fioriere/demetra-f/
Type - Dimensioni - Dimensions: 1800 mm x 600 mm x 480 mm
Type - Generale - Accessori: 1/2 striscia LED; Accessories: 1/2 LED strip; Descrizione Tecnica Famiglia: "Fioriera lineare modulare mod. “DEMETRA FD” costituita da una fioriera monolitica, dotata di un dispositivo di riserva d’acqua integrato che garantisce un giusto grado di umidità del terreno evitando che tutta l’acqua immessa all’interno si disperda."; Descrizione Tecnica per Codice: FIORIERA DEMETRA FD SENZA LIVELLAMENTO IN VERDE ALPI SABBIATO CON BORDI SUPERIORI LEVIGATI VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: freestanding; Technical Description Family: Linear modular planter, model "DEMETRA FD", consisting of a monolithic planter equipped with an integrated water reservoir device that ensures proper soil moisture, preventing the complete dispersion of water added inside.; Technical Description for Article: DEMETRA FD WITHOUT LEVELLING SYSTEM PLANTER IN GREEN ALPS SANDBLASTED WITH POLISHED UPPER RIMS ANTI-DECAY VARNISH
Type - Materiali e finiture - MATERIALE FIORIERA: VERDE ALLPI; Materiale Principale: Pietre Preziose Ricostituite Verde Alpi; Materiale Secondario: Pietre Preziose Ricostituite; Primary Material: Green Alps Reconstituted Precious Stones; Secondary Material: Reconstituted Precious Stone
Type - Meccanica - Weight ( kg): 765 Kg
Pset_BuildingElementProxyCommon - Reference: 0FIAR032 - WITHOUT LEVELLING - VERDE ALPI - 170 Lt
Altro - Famiglia: Fioriera DEMETRA FD: 0FIAR032 - WITHOUT LEVELLING - VERDE ALPI - 170 Lt; Famiglia e tipo: Fioriera DEMETRA FD: 0FIAR032 - WITHOUT LEVELLING - VERDE ALPI - 170 Lt; ID tipo: Fioriera DEMETRA FD: 0FIAR032 - WITHOUT LEVELLING - VERDE ALPI - 170 Lt; Tipo: Fioriera DEMETRA FD: 0FIAR032 - WITHOUT LEVELLING - VERDE ALPI - 170 Lt
Dimensioni - Area: 3.80525 m2; Volume: 0.314706 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
